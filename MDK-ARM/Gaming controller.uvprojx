# Keil uVision project Gaming controller.uvprojx, settings and files
target Gaming controller Configuration (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Gaming controller Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F3xx_HAL_Driver\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\Drivers\Common;..\Drivers\lsm303dlhc;..\Drivers\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303xc.s
  group Application/User
    ../Src/: tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c usbd_desc.c adc.c usbd_conf.c main.c usb_device.c gpio.c i2c.c usbd_cdc_if.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_flash.c stm32f3xx_hal_pcd.c stm32f3xx_hal_adc.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers
    ../Drivers/lsm303dlhc/: lsm303dlhc.c
    ../Drivers/BSP/: stm32f3_discovery_accelerometer.c stm32f3_discovery.c
